# Keil uVision project SEM2306_Lab_Assignment.uvprojx, settings and files
target Debug (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SEM2306_Lab_Assignment +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\Src\BSP;..\Src\BSP\I2C;..\Src\BSP\MCU;..\Src\BSP\SPI;..\Src\App\LCD;..\Src\App\LED;..\Lib\Inc;..\Lib\TIMER
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group App
    ../Src/: main.c
  group App::LED
    ../Src/App/LED/: LED.h
  group App::GUI
    ../Src/App/LCD/: DPGUI_KEIL_CM4_V11.lib LCD_ST7735R.c fontarialbold16.c fontarialbold12.c fontarialbold24.c
  group BSP
    ../Src/BSP/: BSP.c Hal.c IRQ.c Hal.h IRQ.h BSP.h retarget.c
  group BSP::MCU
    ../Src/BSP/MCU/: startup_TM4C123.s system_TM4C123.c
  group BSP::SPI
    ../Src/BSP/SPI/: spim.c spim.h
  group BSP::I2C
    ../Src/BSP/I2C/: i2c.h i2c_sensors.c i2c_sensors.h i2c.lib
  group BSP::TIMER
    ../Lib/TIMER/: timer.h timer.lib
  group Documentation
    ./: Lab Assignment.txt
software components: CMSIS:CORE 5.4.0
